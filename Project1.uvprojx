# Keil uVision project Project1.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MK60DN512xxx10 NXP
  pack: Keil.Kinetis_K60_DFP.1.5.0
  cpu: IROM(0x00000000,0x00080000) IRAM(0x20000000,0x00010000) IRAM2(0x1FFF0000,0x00010000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: Project1
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group Source Group 1
    ./: main.c
  group Led
    ./: Led.c
  group Switch
    ./: Switch.c
software components: CMSIS:CORE 5.0.2, Device:Startup 1.0.0
